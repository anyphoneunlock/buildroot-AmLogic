## package/thirdparty/modskin/Config.in
```kconfig
config BR2_PACKAGE_MODSKIN
depends on BR2_PACKAGE_XBMC
        bool "ModdedConfluence2 Skin"
```
